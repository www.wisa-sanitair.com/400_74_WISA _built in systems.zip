Properties of the parts of a building model (IFC2X3), part 1 of 2

# File
Description: ViewDefinition [CoordinationView]
Time: 2015-03-31T09:14:12
Written by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012
Made in: 20140709_2115(x64) - Exporter 2014.0.2014.0709 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.01.0100.02.64mod : 6 Jun 2012 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Mar 31 09:14:12 2015 * Host: PC-ARN-001 * Database: C:\Users\mdegans\AppData\Local\Temp\{B1F060FE-29A4-4DB4-AEB1-9FCF8C6935B8}\ifc * Database version: 5507 * Database creation date: Tue Mar 31 09:14:05 2015 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Mar 31 09:14:05 2015 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Mar 31 09:14:05 2015 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject
LongName: R:\Revit 2014\02-Te controleren\Bibliotheken\Engels\IFC\400_74_WISA _built in systems.ifc

# IfcSite, Default
RefLatitude: 42, 24, 53, 508911; RefLongitude: -71, -15, -29, -58837; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Constraints - Elevation Base: Project Base Point; Elevation: 0 mm
Graphics - Line Pattern: -3000010; Color: 0; Symbol at End 1 Default: no; Line Weight: 1; Symbol at End 2 Default: yes
Identity Data - Structural: no; Building Story: yes; Name: Level 1
Dimensions - Computation Height: 0 mm

# IfcBuildingElementProxy: Model Text:Model Text 1
In: Level 1
Dimensions - Depth: 50 mm
Identity Data - Subcategory: -2000151
Phasing - Phase Created: New Construction
Constraints - Work Plane: Level : Level 1
Graphics - Text: BUILT-IN SYSTEMS; Horizontal Align: Left
Materials and Finishes - Material: WISA zwart
Pset_BuildingElementProxyCommon - Reference: Model Text 1
Text - Text Size: 600 mm; Bold: no; Italic: no; Text Font: Arial

# IfcBuildingElementProxy: Model Text:Model Text 2 (2)
In: Level 1
Phasing - Phase Created: New Construction
Materials and Finishes - Material: WISA zwart
Identity Data - Subcategory: -2000151
Constraints - Work Plane: Level : Level 1
Graphics - Horizontal Align: Left
Dimensions - Depth: 50 mm
Pset_BuildingElementProxyCommon - Reference: Model Text 2
Text - Text Size: 400 mm; Italic: no; Bold: no; Text Font: Arial
Name (Model Text:...) | Text
Model Text 2 | XS
Model Text 2 | XT

# IfcBuildingElementProxy: Model Text:Model Text 3 (4)
In: Level 1
Graphics - Horizontal Align: Left
Identity Data - Subcategory: -2000151
Phasing - Phase Created: New Construction
Constraints - Work Plane: Level : Level 1
Materials and Finishes - Material: WISA zwart
Dimensions - Depth: 50 mm
Pset_BuildingElementProxyCommon - Reference: Model Text 3
Text - Text Font: Arial; Bold: no; Text Size: 200 mm; Italic: no
Name (Model Text:...) | Text
2 x Model Text 3 | TOILET SYSTEMS
Model Text 3 | URINAL- AND WT SYSTEMS
Model Text 3 | OTHER SYSTEMS

# IfcFlowTerminal: all in one no1_wisa_closet combination, RSen_74_PF_FB_closet combination all-in one no1_wisa:all in one no1_wisa_closet combination:3954530
In: Level 1
Type - ElementType: all in one no1_wisa_closet combination; PredefinedType: CISTERN; Classification: 4A(74.22) ingebouwde sanitaire voorzieningen (UniFormat); Material: RSen_g3_porcelain_white, RSen_n6_PEXa_white, RSen_h2_steel_blue, RSen_n6_PEXa_yellow
Plumbing - cw_connection_above: yes; sewage_angle: 0 deg; cw_connection_behind: no; sewage_length: 222 mm; sewage_diameter_90: no; sewage_diameter_110: yes; sewage_initial adjustment depth: 0 mm
Construction - threaded rod_180: yes; initial adjustment_depth: 200 mm; initial adjustment_height: 0 mm; threaded rod_230: no; front wall_thickness: 0 mm
Dimensions - Rsen_P_c02_diameter: 110 mm; Rsen_P_c02_angle: 0 deg; Rsen_C_depth: 200 mm; rs_C_guest_mounting height: 230 mm; Rsen_C_width: 380 mm; Rsen_P_c01_diameter: 15 mm; Rsen_C_height: 1180 mm
Other - Schedule Level: Level: Level 1; calc_front wall_thickness: 3 mm; calc_initial adjustment_height: 0 mm; calc_initial adjustment_depth: 200 mm; origin: 0 mm; calc_sewage_distance: 88 mm; calc_threaded rod: 180 mm; cw_height: 85 mm; calc_sewage: 88 mm; cw_depth: 73 mm; calc_dist_connection_angle: 88 mm; calc_sewage_length: 222 mm; cw_angle: 90 deg
Constraints - inbouw: no; Host: Reference Plane; Elevation: 0 mm; Default Elevation: 0 mm
Identity Data - Mark: 1763; NLRS_C_revit_versie: 2014; Rsen_C_code_STABU: 53.31; Rsen_C_code_ETIM: EC011318; Rsen_C_model: XS; Rsen_C_code_SfB_table1: 74.22; Model: XS; Rsen_C_code_manufacturer_product: 8050435001; Assembly Description: ingebouwde sanitaire voorzieningen; Manufacturer: WISA; Rsen_C_code_gtin: 8711778126770; Description: WISA all in one pack no.1; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC011318&ArtClassVersion=5; Assembly Code: 4A(74.22); Rsen_C_type_comments: Wandclosetcombinatie; Type Comments: Closet combination; Rsen_C_code_manufacturer_gln: 8711778000001; Rsen_C_description: WISA all in one pack no.1
Mechanical - System Classification: Sanitary,Domestic Cold Water; Rsen_P_c02_fixture units: 0; WFU: 0; CWFU: 0; Rsen_P_c01_fixture units: 0
Model Properties - corner fixation set: no
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: WISA
Mechanical - Flow - flush_volume: 0.26486 ft3
Text - Rsen_P_c02_definition: c02_sewage; water connection: G 1/2; Rsen_P_c01_definition: c01_cw
Materials and Finishes - Rsen_C_material_01: RSen_h2_steel_blue
General - Rsen_C_content_creator: WISA

# IfcFlowTerminal: bidet element_wisa_built in element bidet, RSen_74_PF_FB_built in element bidet_wisa:bidet element_wisa_built in element bidet:3977733
In: Level 1
Type - ElementType: bidet element_wisa_built in element bidet; PredefinedType: BIDET; Classification: 4A(74.22) ingebouwde sanitaire voorzieningen (UniFormat); Material: RSen_h2_steel_blue
General - Rsen_C_content_creator: WISA
Text - Rsen_P_c01_definition: c01_sewage
Materials and Finishes - Rsen_C_material_01: RSen_h2_steel_blue
Mechanical - Rsen_P_c01_fixture units: 0; WFU: 0; CWFU: 0; System Classification: Sanitary
Dimensions - Rsen_C_width: 575 mm; Rsen_C_height: 1180 mm; Rsen_C_depth: 200 mm; Rsen_P_c01_diameter: 50 mm
Constraints - Default Elevation: 0 mm; Host: Reference Plane; Elevation: 0 mm; inbouw: no
Identity Data - Manufacturer: WISA; Type Comments: Built-in element bidet; Rsen_C_code_SfB_table1: 74.22; Rsen_C_code_manufacturer_gln: 8711778000001; Rsen_C_code_ETIM: EC011368; Rsen_C_code_STABU: 53.31; Description: WISA XS bidet frame; Rsen_C_code_gtin: 8711778103726; Rsen_C_code_manufacturer_product: 8050452911; URL: www.wisa-sanitair.com/nl/8050452911; Model: XS; Assembly Code: 4A(74.22); Assembly Description: ingebouwde sanitaire voorzieningen; Rsen_C_description: WISA bidet element; NLRS_C_revit_versie: 2014; Rsen_C_model: XS; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC011368&ArtClassVersion=4; Rsen_C_type_comments: Bidetframe; Mark: 1774
Plumbing - sewage_initial adjustment depth: 0 mm; sewage_diameter_50: yes; sewage_diameter_40: no
Construction - threaded rod_180: no; cross section_position: 6; front wall_thickness: 0 mm; initial adjustment_height: 0 mm; initial adjustment_depth: 200 mm; threaded rod_230: yes
Other - origin: 0 mm; calc_cross section_position: 262 mm; calc_front wall_thickness: 3 mm; calc_threaded rod: 230 mm; calc_initial adjustment_height: 0 mm; Schedule Level: Level: Level 1; calc_initial adjustment_depth: 200 mm
Model Properties - corner fixation set: no
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: WISA

# IfcFlowTerminal: sink_wisa_built in element slop sink, RSen_74_PF_FB_built in element slop sink_wisa:sink_wisa_built in element slop sink:3977991
In: Level 1
Type - ElementType: sink_wisa_built in element slop sink; PredefinedType: SINK; Classification: 4A(74.22) ingebouwde sanitaire voorzieningen (UniFormat); Material: RSen_i4_boarding_uderlayment, RSen_h2_steel_blue
General - Rsen_C_content_creator: WISA
Constraints - Default Elevation: 0 mm; Host: Reference Plane; Elevation: 0 mm; inbouw: no
Materials and Finishes - Rsen_C_material_02: RSen_i4_boarding_uderlayment; Rsen_C_material_01: RSen_h2_steel_blue
Dimensions - Rsen_C_height: 1180 mm; Rsen_C_width: 575 mm; Rsen_P_c01_diameter: 50 mm; Rsen_C_depth: 135 mm; height_02: 742 mm; height_01: 470 mm; height_03: 1075 mm
Text - Rsen_C_definition_01: Cross section; Rsen_C_definition_02: Fixation plate under; Rsen_C_definition_03: Upper mounting plate; Rsen_P_c01_definition: c01_sewage
Mechanical - Rsen_P_c01_fixture units: 0; CWFU: 0; WFU: 0; System Classification: Sanitary
Identity Data - Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC011505&ArtClassVersion=3; Assembly Description: ingebouwde sanitaire voorzieningen; Manufacturer: WISA; Rsen_C_type_comments: Uitstortgootsteenframe; Rsen_C_code_ETIM: EC011505; URL: www.wisa-sanitair.com/nl/8050452724; Description: WISA XS sink frame; Rsen_C_code_manufacturer_product: 8050452724; Model: XS; NLRS_C_revit_versie: 2014; Assembly Code: 4A(74.22); Rsen_C_description: WISA uitstortgootsteen element; Rsen_C_code_STABU: 53.31; Type Comments: Double wall/built-in element slop sink; Rsen_C_model: XS; Rsen_C_code_SfB_table1: 74.22; Rsen_C_code_gtin: 8711778121119; Rsen_C_code_manufacturer_gln: 8711778000001; Mark: 1776
Other - calc_initial adjustment_height: 0 mm; origin: 0 mm; calc_initial adjustment_depth: 135 mm; Rsen_C_height_03: 1075 mm; Rsen_C_height_01: 470 mm; calc_front wall_thickness: 3 mm; Schedule Level: Level: Level 1; Rsen_C_height_02: 742 mm
Phasing - Phase Created: New Construction
Construction - initial adjustment_height: 0 mm; initial adjustment_depth: 0 mm; front wall_thickness: 0 mm
Model Properties - corner fixation set: no
Pset_ManufacturerTypeInformation - Manufacturer: WISA

# IfcFlowTerminal: urinal xs electronic_wisa_built-in element urinal, RSen_74_PF_FB_built-in element urinal xs electronic_wisa:urinal xs electronic_wisa_built-in element urinal:3964992
In: Level 1
Type - ElementType: urinal xs electronic_wisa_built-in element urinal; PredefinedType: URINAL; Classification: 4A(74.22) ingebouwde sanitaire voorzieningen (UniFormat); Material: RSen_n6_PE_black, RSen_n6_PEXa_white, RSen_h2_steel_blue, RSen_i4_boarding_uderlayment
Construction - initial adjustment_height: 200 mm; height_04: 875 mm; height_02: 520 mm; height_01: 395 mm; width_03: 230 mm; height_03: 645 mm; front wall_thickness: 0 mm; initial adjustment_depth: 200 mm
Identity Data - Mark: 1769; Rsen_C_code_gtin: 8711778125735; Rsen_C_code_SfB_table1: 74.22; Rsen_C_type_comments: Urinoirframe; Assembly Description: ingebouwde sanitaire voorzieningen; Rsen_C_code_manufacturer_product: 8050452756; Type Comments: Double wall/built-in element urinal; Rsen_C_code_manufacturer_gln: 8711778000001; Model: XS; Manufacturer: WISA; Rsen_C_description: WISA XS urinalframe with pre-assembled siphon controlled electronic flushing; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC011370&ArtClassVersion=5; Assembly Code: 4A(74.22); Rsen_C_code_STABU: 53.31; Rsen_C_code_ETIM: EC011370; Rsen_C_model: XS; Rsen_C_revit_version: 2014; URL: www.wisa-sanitair.com/nl/8050452756; Description: WISA XS urinalframe with pre-assembled siphon controlled electronic flushing
Phasing - Phase Created: New Construction
Other - calc_initial adjustment_height: 200 mm; Rsen_C_width_03: 230 mm; Rsen_C_height_04: 875 mm; calc_front wall_thickness: 3 mm; calc_initial adjustment_depth: 200 mm; Rsen_C_height_03: 645 mm; Rsen_C_height_02: 520 mm; Rsen_C_height_05: 405 mm; origin: 0 mm; Rsen_C_height_01: 395 mm; Schedule Level: Level: Level 1
Mechanical - System Classification: Sanitary; WFU: 0; Rsen_P_c01_fixture units: 0
Model Properties - corner fixation set: no
Constraints - inbouw: no; Elevation: 0 mm; Host: Reference Plane; Default Elevation: 0 mm
Plumbing - height_05: 405 mm
Dimensions - Rsen_C_depth: 200 mm; Rsen_C_width: 380 mm; Rsen_C_height: 1180 mm; Rsen_P_c01_diameter: 50 mm
Text - Rsen_P_c01_definition: c01_sewage; Rsen_C_definition_03: Threaded rods; Rsen_C_definition_02: Fixation plate under; Rsen_C_definition_01: Bracket holder; Rsen_C_definition_04: Upper mounting plate; water connection: G1/2; Rsen_C_definition_05: Drain pipe
Pset_ManufacturerTypeInformation - Manufacturer: WISA
General - Rsen_C_content_creator: WISA
Materials and Finishes - Rsen_C_material_02: RSen_n6_PEXa_white; Rsen_C_material_01: RSen_h2_steel_blue; Rsen_C_material_04: RSen_i4_boarding_uderlayment; Rsen_C_material_03: RSen_n6_PE_black

# IfcFlowTerminal: xf wc frame_wisa_inbouwreservoir, RSen_74_PF_FB_built in element xf wc frame_wisa:xf wc frame_wisa_inbouwreservoir:3997138
In: Level 1
Type - ElementType: xf wc frame_wisa_inbouwreservoir; PredefinedType: CISTERN; Classification: 4A(74.22) ingebouwde sanitaire voorzieningen (UniFormat); Material: RSen_n6_PEXa_white, RSen_h2_steel_blue
Mechanical - Flow - flush_volume: 0.26486 ft3
General - Rsen_C_content_creator: WISA
Constraints - Default Elevation: 0 mm; inbouw: no; Host: Reference Plane; Elevation: 0 mm
Materials and Finishes - Rsen_C_material_01: RSen_h2_steel_blue; Rsen_C_material: RSen_n6_PEXa_white
Dimensions - Rsen_P_c01_diameter: 15 mm; Rsen_C_width: 461 mm; Rsen_C_height: 847 mm; Rsen_C_depth: 200 mm
Identity Data - Description: WISA XF WC front docol; Type Comments: Built-in element wall-hung closet with flushing reservoir; Rsen_C_type_comments: Built-in element wall-hung closet with flushing reservoir; Rsen_C_code_STABU: 53.31; Assembly Description: ingebouwde sanitaire voorzieningen; Rsen_C_description: WISA XF WC front; Rsen_C_code_manufacturer_product: 8050452500; Rsen_C_model: XF; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC010145&ArtClassVersion=4; Rsen_C_code_ETIM: EC010145; Manufacturer: WISA; Assembly Code: 4A(74.22); Model: XF; NLRS_C_revit_versie: 2014; Rsen_C_code_manufacturer_gln: 8711778000001; Rsen_C_code_SfB_table1: 74.22; Rsen_C_code_gtin: 8711778168572; Mark: 1785
Mechanical - WFU: 0; Rsen_P_c01_fixture units: 0; CWFU: 0; System Classification: Domestic Cold Water
Text - Rsen_P_c01_definition: c01_cw; water connection: G 1/2
Other - calc_initial adjustment_depth: 200 mm; Schedule Level: Level: Level 1; calc_front wall_thickness: 15 mm; calc_initial adjustment_height: 200 mm; origin: 0 mm
Construction - front wall_thickness: 0 mm; initial adjustment_height: 200 mm; initial adjustment_depth: 200 mm
Model Properties - control panel: RSen_74_PF_FB_control panel xt_wisa: ▼ choose
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: WISA

# IfcFlowTerminal: xs bath shower mixingtapframe_wisa_bath shower mixingtapframe, RSen_74_PF_FB_bath shower mixingtapframe xs_wisa:xs bath shower mixingtapframe_wisa_bath shower mixingtapframe:3977945
In: Level 1
Type - ElementType: xs bath shower mixingtapframe_wisa_bath shower mixingtapframe; PredefinedType: SHOWER; Classification: 4A(74.22) ingebouwde sanitaire voorzieningen (UniFormat); Material: RSen_i4_boarding_uderlayment, RSen_h2_steel_blue
General - Rsen_C_content_creator: WISA
Mechanical - CWFU: 0; WFU: 0
Materials and Finishes - Rsen_C_material_01: RSen_h2_steel_blue; Rsen_C_material_02: RSen_i4_boarding_uderlayment
Dimensions - Rsen_C_height: 1180 mm; Rsen_C_width: 380 mm; Rsen_C_depth: 200 mm; height_01: 1041.5 mm
Constraints - Default Elevation: 0 mm; inbouw: no; Elevation: 0 mm; Host: Reference Plane
Identity Data - Manufacturer: WISA; Rsen_C_code_gtin: 8711778121188; NLRS_C_revit_versie: 2014; Rsen_C_model: XS; Model: XS; Assembly Description: ingebouwde sanitaire voorzieningen; Rsen_C_description: WISA XS bath/shower frame; Rsen_C_type_comments: Bath shower mixingtapframe; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC010089&ArtClassVersion=3; Description: WISA XS bath/shower frame; Rsen_C_code_manufacturer_gln: 8711778000001; URL: www.wisa-sanitair.com/nl/8050452741; Rsen_C_code_STABU: 53.31; Rsen_C_code_manufacturer_product: 8050452741; Assembly Code: 4A(74.22); Rsen_C_code_SfB_table1: 74.22; Type Comments: Bath shower mixingtapframe; Rsen_C_code_ETIM: EC010089; Mark: 1775
Construction - front wall_thickness: 0 mm; initial adjustment_height: 0 mm; initial adjustment_depth: 200 mm
Other - Schedule Level: Level: Level 1; Rsen_C_height_01: 1041.5 mm; origin: 0 mm; calc_initial adjustment_depth: 200 mm; calc_initial adjustment_height: 0 mm; calc_front wall_thickness: 3 mm
Phasing - Phase Created: New Construction
Model Properties - corner fixation set: no
Pset_ManufacturerTypeInformation - Manufacturer: WISA

# IfcFlowTerminal: xs l wc frame with support plate_wisa_built in element, RSen_74_PF_FB_built in element xs l wc frame with support plate_wisa:xs l wc frame with support plate_wisa_built in element:3948436
In: Level 1
Type - ElementType: xs l wc frame with support plate_wisa_built in element; PredefinedType: CISTERN; Classification: 4A(74.22) ingebouwde sanitaire voorzieningen (UniFormat); Material: RSen_h2_steel_blue, RSen_n6_PEXa_yellow, RSen_n6_PEXa_white, RSen_i4_boarding_uderlayment
Other - origin: 0 mm; calc_sewage_distance: 88 mm; calc_dist_connection_angle: 88 mm; cw_height: 85 mm; cw_angle: 90 deg; calc_front wall_thickness: 3 mm; cw_depth: 73 mm; calc_threaded rod: 230 mm; calc_sewage: 88 mm; Schedule Level: Level: Level 1; calc_sewage_length: 222 mm; calc_initial adjustment_depth: 200 mm; calc_initial adjustment_height: 0 mm
Plumbing - sewage_length: 222 mm; cw_connection_behind: no; sewage_initial adjustment depth: 0 mm; cw_connection_above: yes; sewage_diameter_90: no; sewage_angle: 0 deg; sewage_diameter_110: yes
Dimensions - Rsen_C_depth: 200 mm; Rsen_C_width: 890 mm; Rsen_P_c02_angle: 0 deg; Rsen_P_c02_diameter: 110 mm; rs_C_guest_mounting height: 230 mm; Rsen_C_height: 1180 mm; Rsen_P_c01_diameter: 15 mm
Construction - threaded rod_230: yes; threaded rod_180: no; initial adjustment_depth: 200 mm; initial adjustment_height: 0 mm; front wall_thickness: 0 mm
Phasing - Phase Created: New Construction
Identity Data - Mark: 1753; Rsen_C_code_ETIM: EC010145; Assembly Description: ingebouwde sanitaire voorzieningen; Rsen_C_description: WISA XS L WC front met steunbeugelelementen; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC010145&ArtClassVersion=4; Rsen_C_code_manufacturer_gln: 8711778000001; Assembly Code: 4A(74.22); Rsen_C_code_gtin: 8711778158849; NLRS_C_revit_versie: 2014; Manufacturer: WISA; Rsen_C_code_STABU: 53.31; Rsen_C_code_manufacturer_product: 8050452737; Rsen_C_code_SfB_table1: 74.22; Rsen_C_type_comments: Inbouwreservoir; Model: XS; Description: WISA XS L WC frame 90/110 mm with support plate; Type Comments: Built-in element wall-hung closet with flushing reservoir; Rsen_C_model: XS; URL: www.wisa-sanitair.com/nl/8050452737
Model Properties - control panel: RSen_74_PF_FB_control panel_wisa: ▼ choose
Mechanical - System Classification: Sanitary,Domestic Cold Water; WFU: 0; CWFU: 0; Rsen_P_c02_fixture units: 0; Rsen_P_c01_fixture units: 0
Constraints - inbouw: no; Elevation: 0 mm; Host: Reference Plane; Default Elevation: 0 mm
Pset_ManufacturerTypeInformation - Manufacturer: WISA
Materials and Finishes - Rsen_C_material_02: RSen_i4_boarding_uderlayment; Rsen_C_material_01: RSen_h2_steel_blue
Mechanical - Flow - flush_volume: 0.26486 ft3
Text - Rsen_P_c02_definition: c02_sewage; Rsen_P_c01_definition: c01_cw; water connection: G 1/2
General - Rsen_C_content_creator: WISA

# IfcFlowTerminal: xs l wc frame_wisa_built in element, RSen_74_PF_FB_built in element xs l wc frame_wisa:xs l wc frame_wisa_built in element:3948379
In: Level 1
Type - ElementType: xs l wc frame_wisa_built in element; PredefinedType: CISTERN; Classification: 4A(74.22) ingebouwde sanitaire voorzieningen (UniFormat); Material: RSen_h2_steel_blue, RSen_n6_PEXa_yellow, RSen_n6_PEXa_white
Construction - threaded rod_230: yes; frame_left_distance: 0 mm; threaded rod_180: no; initial adjustment_height: 0 mm; front wall_thickness: 0 mm; initial adjustment_depth: 200 mm; frame_right_distance: 0 mm
Plumbing - cw_connection_behind: no; sewage_length: 222 mm; sewage_diameter_110: yes; sewage_angle: 0 deg; cw_connection_above: yes; sewage_initial adjustment depth: 0 mm; sewage_diameter_90: no
Model Properties - control panel: RSen_74_PF_FB_control panel_wisa: ▼ choose
Other - calc_frame_left_distance: 390 mm; calc_initial adjustment_depth: 200 mm; calc_front wall_thickness: 3 mm; origin: 0 mm; calc_dist_connection_angle: 88 mm; calc_sewage_length: 222 mm; calc_sewage_distance: 88 mm; cw_angle: 90 deg; calc_initial adjustment_height: 0 mm; calc_sewage: 88 mm; cw_height: 85 mm; Schedule Level: Level: Level 1; calc_threaded rod: 230 mm; calc_frame_right_distance: 390 mm; cw_depth: 73 mm
Mechanical - System Classification: Sanitary,Domestic Cold Water; Rsen_P_c01_fixture units: 0; WFU: 0; CWFU: 0; Rsen_P_c02_fixture units: 0
Dimensions - Rsen_C_width: 780 mm; Rsen_C_depth: 200 mm; Rsen_P_c02_diameter: 110 mm; Rsen_P_c02_angle: 0 deg; rs_C_guest_mounting height: 230 mm; Rsen_C_height: 1180 mm; Rsen_P_c01_diameter: 15 mm
Constraints - Host: Reference Plane; Elevation: 0 mm; inbouw: no; Default Elevation: 0 mm
Identity Data - Mark: 1751; Assembly Code: 4A(74.22); Manufacturer: WISA; NLRS_C_revit_versie: 2014; Rsen_C_code_SfB_table1: 74.22; Model: XS; Rsen_C_description: WISA XS L WC front; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC010145&ArtClassVersion=4; Rsen_C_type_comments: Built-in element wall-hung closet with flushing reservoir; Description: WISA XS L WC frame 90/110 mm; Type Comments: Built-in element wall-hung closet with flushing reservoir; Assembly Description: ingebouwde sanitaire voorzieningen; Rsen_C_model: XS; Rsen_C_code_gtin: 8711778141452; URL: www.wisa-sanitair.com/nl/8050452707; Rsen_C_code_manufacturer_gln: 8711778000001; Rsen_C_code_manufacturer_product: 8050452707; Rsen_C_code_STABU: 53.31; Rsen_C_code_ETIM: EC010145
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: WISA
Materials and Finishes - Rsen_C_material_01: RSen_h2_steel_blue
Text - Rsen_P_c02_definition: c02_sewage; Rsen_P_c01_definition: c01_cw; water connection: G 1/2
General - Rsen_C_content_creator: WISA
Mechanical - Flow - flush_volume: 0.26486 ft3

# IfcFlowTerminal: xs mont wc frame_wisa_built in element, RSen_74_PF_FB_built in element xs mont wc frame_wisa:xs mont wc frame_wisa_built in element:3980799
In: Level 1
Type - ElementType: xs mont wc frame_wisa_built in element; PredefinedType: CISTERN; Classification: 4A(74.22) ingebouwde sanitaire voorzieningen (UniFormat); Material: RSen_h2_steel_blue, RSen_n6_PEXa_yellow, RSen_n6_PEXa_white
Dimensions - Rsen_C_height: 1180 mm; Rsen_P_c01_diameter: 15 mm; rs_C_guest_mounting height: 230 mm; Rsen_C_width: 380 mm; Rsen_P_c02_angle: 0 deg; Rsen_C_depth: 140 mm; Rsen_P_c02_diameter: 110 mm
General - Rsen_C_content_creator: WISA
Text - Rsen_P_c01_definition: c01_cw; Rsen_P_c02_definition: c02_sewage; water connection: G 1/2
Mechanical - Flow - flush_volume: 0.26486 ft3
Materials and Finishes - Rsen_C_material_01: RSen_h2_steel_blue
Mechanical - WFU: 0; CWFU: 0; Rsen_P_c01_fixture units: 0; Rsen_P_c02_fixture units: 0; System Classification: Sanitary,Domestic Cold Water
Constraints - Default Elevation: 0 mm; Host: Reference Plane; Elevation: 0 mm; inbouw: no
Identity Data - Rsen_C_code_gtin: 8711778121041; Rsen_C_code_STABU: 53.31; Manufacturer: WISA; Rsen_C_code_manufacturer_product: 8050452104; URL: www.wisa-sanitair.com/nl/8050452104; NLRS_C_revit_versie: 2014; Assembly Code: 4A(74.22); Rsen_C_model: XS; Rsen_C_description: XS Mont WC front; Rsen_C_code_ETIM: EC010145; Rsen_C_code_SfB_table1: 74.22; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC010145&ArtClassVersion=4; Rsen_C_code_manufacturer_gln: 8711778000001; Description: XS Mont WC front; Rsen_C_type_comments: Built-in element wall-hung closet with flushing reservoir; Type Comments: Built-in element wall-hung closet with flushing reservoir; Model: XS; Assembly Description: ingebouwde sanitaire voorzieningen; Mark: 1777
Plumbing - cw_connection_behind: no; sewage_angle: 0 deg; sewage_length: 222 mm; cw_connection_above: yes; sewage_initial adjustment depth: 0 mm; sewage_diameter_90: no; sewage_diameter_110: yes
Other - origin: 0 mm; calc_sewage_length: 222 mm; Schedule Level: Level: Level 1; cw_depth: 73 mm; calc_sewage: 88 mm; calc_front wall_thickness: 3 mm; calc_dist_connection_angle: 88 mm; calc_threaded rod: 230 mm; cw_angle: 90 deg; calc_sewage_distance: 88 mm; calc_initial adjustment_depth: 140 mm; cw_height: 85 mm
Construction - threaded rod_230: yes; threaded rod_180: no; front wall_thickness: 0 mm
Phasing - Phase Created: New Construction
Model Properties - control panel: RSen_74_PF_FB_control panel_wisa: ▼ choose
Pset_ManufacturerTypeInformation - Manufacturer: WISA

# IfcFlowTerminal: xs toilet support_wisa_built in element armrest, RSen_74_PF_FB_built in element armrest xs toilet support_wisa:xs toilet support_wisa_built in element armrest:3977669
In: Level 1
Type - ElementType: xs toilet support_wisa_built in element armrest; PredefinedType: USERDEFINED; Classification: 4A(74.22) ingebouwde sanitaire voorzieningen (UniFormat); Material: RSen_i4_boarding_uderlayment, RSen_h2_steel_blue
Constraints - Default Elevation: 0 mm; Elevation: 0 mm; inbouw: no; Host: Reference Plane
General - Rsen_C_content_creator: WISA
Materials and Finishes - Rsen_C_material_02: RSen_i4_boarding_uderlayment; Rsen_C_material_01: RSen_h2_steel_blue
Mechanical - WFU: 0; CWFU: 0
Dimensions - Rsen_C_width: 380 mm; Rsen_C_height: 1180 mm; Rsen_C_depth: 200 mm
Identity Data - Rsen_C_code_STABU: 53.31; Rsen_C_code_manufacturer_product: 8050452997; Rsen_C_code_ETIM: EC010929; Rsen_C_code_gtin: 8711778103788; Description: WISA XS Support frame; Assembly Description: ingebouwde sanitaire voorzieningen; Rsen_C_code_manufacturer_gln: 8711778000001; Rsen_C_type_comments: Toiletsteunframe; URL: www.wisa-sanitair.com/nl/8050452997; Manufacturer: WISA; Rsen_C_code_SfB_table1: 74.22; Model: XS; Type Comments: Double wall/built-in element armrest; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC010929&ArtClassVersion=3; Rsen_C_model: XS; Assembly Code: 4A(74.22); Rsen_C_description: WISA XS Support frame; NLRS_C_revit_versie: 2014; Mark: 1773
Other - calc_front wall_thickness: 3 mm; Schedule Level: Level: Level 1; origin: 0 mm; calc_initial adjustment_height: 0 mm; calc_initial adjustment_depth: 200 mm
Phasing - Phase Created: New Construction
Construction - initial adjustment_depth: 200 mm; initial adjustment_height: 0 mm; front wall_thickness: 0 mm
Model Properties - corner fixation set: no
Pset_ManufacturerTypeInformation - Manufacturer: WISA

# IfcFlowTerminal: xs urinal mechanic for panel square_wisa_built-in element urinal, RSen_74_PF_FB_built-in element urinal xs mechanic for panel square_wisa:xs urinal mechanic for panel square_wisa_built-in element urinal:3964835
In: Level 1
Type - ElementType: xs urinal mechanic for panel square_wisa_built-in element urinal; PredefinedType: URINAL; Classification: 4A(74.22) ingebouwde sanitaire voorzieningen (UniFormat); Material: RSen_n6_PE_black, RSen_i4_boarding_uderlayment, RSen_h2_steel_blue
Other - origin: 0 mm; calc_initial adjustment_height: 0 mm; calc_initial adjustment_depth: 135 mm; Rsen_C_height_01: 470 mm; Rsen_C_height_02: 685 mm; Schedule Level: Level: Level 1; Rsen_C_height_03: 808 mm; calc_front wall_thickness: 3 mm; Rsen_C_width_03: 180 mm; Rsen_C_height_04: 1005 mm
Constraints - Elevation: 0 mm; inbouw: no; Host: Reference Plane; Default Elevation: 0 mm
Phasing - Phase Created: New Construction
Construction - initial adjustment_height: 0 mm; front wall_thickness: 0 mm; initial adjustment_depth: 0 mm
Mechanical - System Classification: Sanitary,Domestic Cold Water; CWFU: 0; Rsen_P_c02_fixture units: 0; Rsen_P_c01_fixture units: 0; WFU: 0
Model Properties - corner fixation set: no; control panel: RSen_74_PF_FB_control panel_wisa: ▼ choose
Dimensions - height_04: 1005 mm; height_03: 808 mm; width_03: 180 mm; height_01: 470 mm; Rsen_C_depth: 135 mm; height_02: 685 mm; Rsen_P_c01_diameter: 15 mm; Rsen_P_c02_diameter: 50 mm; Rsen_C_height: 1180 mm; Rsen_C_width: 380 mm
Identity Data - Mark: 1765; Rsen_C_code_manufacturer_gln: 8711778000001; NLRS_C_revit_versie: 2014; Rsen_C_description: WISA XS urinoir mechanisch voor paneel Square; Rsen_C_code_STABU: 53.31; Rsen_C_model: XS; Rsen_C_code_ETIM: EC011370; Manufacturer: WISA; Rsen_C_code_gtin: 8711778137875; Model: XS; Assembly Description: ingebouwde sanitaire voorzieningen; Type Comments: Double wall/built-in element urinal; Rsen_C_type_comments: Urinoirframe; Rsen_C_code_SfB_table1: 74.22; Assembly Code: 4A(74.22); URL: www.wisa-sanitair.com/nl/8050452758; Description: WISA XS urinal with pressure flush for panel Square; Rsen_C_code_manufacturer_product: 8050452758; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC011370&ArtClassVersion=5
Pset_ManufacturerTypeInformation - Manufacturer: WISA
Text - Rsen_C_definition_01: Cross section; Rsen_P_c01_definition: c01_cw; Rsen_C_definition_04: Upper mounting plate; Rsen_P_c02_definition: c02_sewage; Rsen_C_definition_03: Fixation plate under; Rsen_C_definition_02: Threaded rods
Materials and Finishes - Rsen_C_material_03: RSen_n6_PE_black; Rsen_C_material_02: RSen_i4_boarding_uderlayment; Rsen_C_material_01: RSen_h2_steel_blue
General - Rsen_C_content_creator: WISA

# IfcFlowTerminal: xs urinal mechanic_wisa_built-in element urinal, RSen_74_PF_FB_built-in element urinal xs mechanic_wisa:xs urinal mechanic_wisa_built-in element urinal:3964918
In: Level 1
Type - ElementType: xs urinal mechanic_wisa_built-in element urinal; PredefinedType: URINAL; Classification: 4A(74.22) ingebouwde sanitaire voorzieningen (UniFormat); Material: RSen_n6_PE_black, RSen_i4_boarding_uderlayment, RSen_h2_steel_blue
Construction - initial adjustment_height: 0 mm; front wall_thickness: 0 mm; initial adjustment_depth: 0 mm
Other - origin: 0 mm; calc_front wall_thickness: 3 mm; Rsen_C_height_03: 808 mm; Rsen_C_height_01: 470 mm; calc_initial adjustment_height: 0 mm; Rsen_C_height_04: 1005 mm; calc_initial adjustment_depth: 135 mm; Rsen_C_width_03: 180 mm; Rsen_C_height_02: 685 mm; Schedule Level: Level: Level 1
Dimensions - height_03: 808 mm; height_04: 1005 mm; height_01: 470 mm; width_03: 180 mm; Rsen_C_depth: 135 mm; height_02: 685 mm; Rsen_C_width: 380 mm; Rsen_C_height: 1180 mm; Rsen_P_c02_diameter: 50 mm; Rsen_P_c01_diameter: 15 mm
Phasing - Phase Created: New Construction
Mechanical - System Classification: Sanitary,Domestic Cold Water; Rsen_P_c02_fixture units: 0; Rsen_P_c01_fixture units: 0; CWFU: 0; WFU: 0
Constraints - inbouw: no; Elevation: 0 mm; Host: Reference Plane; Default Elevation: 0 mm
Identity Data - Mark: 1767; Rsen_C_code_manufacturer_product: 8050452757; Rsen_C_code_gtin: 8711778158337; Rsen_C_code_ETIM: EC011370; Assembly Description: ingebouwde sanitaire voorzieningen; Rsen_C_model: XS; Rsen_C_description: WISA XS urinal with pressure flush for urinal panels XS; Rsen_C_type_comments: Double wall/built-in element urinal; Type Comments: Double wall/built-in element urinal; Rsen_C_code_STABU: 53.31; NLRS_C_revit_versie: 2014; URL: www.wisa-sanitair.com/nl/8050452757; Description: WISA XS urinal with pressure flush for urinal panels XS; Rsen_C_code_SfB_table1: 74.22; Manufacturer: WISA; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC011370&ArtClassVersion=5; Model: XS; Assembly Code: 4A(74.22); Rsen_C_code_manufacturer_gln: 8711778000001
Model Properties - control panel: RSen_74_PF_FB_control panel_wisa: ▼ choose; corner fixation set: no
Pset_ManufacturerTypeInformation - Manufacturer: WISA
Materials and Finishes - Rsen_C_material_01: RSen_h2_steel_blue; Rsen_C_material_03: RSen_n6_PE_black; Rsen_C_material_02: RSen_i4_boarding_uderlayment
Text - Rsen_P_c02_definition: c02_sewage; Rsen_C_definition_02: Threaded rods; Rsen_P_c01_definition: c01_cw; Rsen_C_definition_03: Fixation plate under; Rsen_C_definition_04: Upper mounting plate; Rsen_C_definition_01: Cross section
General - Rsen_C_content_creator: WISA

# IfcFlowTerminal: xs urinal_wisa_built-in element urinal, RSen_74_PF_FB_built-in element urinal_wisa:xs urinal_wisa_built-in element urinal:3964741
In: Level 1
Type - ElementType: xs urinal_wisa_built-in element urinal; PredefinedType: URINAL; Classification: 4A(74.22) ingebouwde sanitaire voorzieningen (UniFormat); Material: RSen_i4_boarding_uderlayment, RSen_h2_steel_blue
Other - calc_initial adjustment_height: 0 mm; origin: 0 mm; Schedule Level: Level: Level 1; calc_initial adjustment_depth: 135 mm; Rsen_C_height_04: 1005 mm; Rsen_C_height_03: 808 mm; Rsen_C_height_02: 685 mm; calc_front wall_thickness: 3 mm; Rsen_C_width_03: 180 mm; Rsen_C_height_01: 470 mm
Identity Data - Mark: 1764; Rsen_C_code_manufacturer_gln: 8711778000001; NLRS_C_revit_versie: 2014; Rsen_C_code_gtin: 8711778118645; Type Comments: Double wall/built-in element urinal; Model: XS; Description: WISA XS urinal-frame; Assembly Description: ingebouwde sanitaire voorzieningen; Rsen_C_code_manufacturer_product: 8050452751; Rsen_C_type_comments: Urinoirframe; Rsen_C_code_ETIM: EC011370; Assembly Code: 4A(74.22); Rsen_C_code_SfB_table1: 74.22; Rsen_C_model: XS; Manufacturer: WISA; URL: www.wisa-sanitair.com/nl/8050452751; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC011370&ArtClassVersion=5; Rsen_C_description: WISA XS urinoir; Rsen_C_code_STABU: 53.31
Mechanical - System Classification: Sanitary; WFU: 0; CWFU: 0; Rsen_P_c02_fixture units: 0; Rsen_P_c01_fixture units: 0
Construction - front wall_thickness: 0 mm; initial adjustment_height: 0 mm; initial adjustment_depth: 0 mm
Model Properties - corner fixation set: no
Phasing - Phase Created: New Construction
Dimensions - Rsen_C_depth: 135 mm; height_01: 470 mm; height_02: 685 mm; width_03: 180 mm; height_03: 808 mm; height_04: 1005 mm; Rsen_C_height: 1180 mm; Rsen_P_c01_diameter: 15 mm; Rsen_C_width: 380 mm; Rsen_P_c02_diameter: 50 mm
Constraints - Host: Reference Plane; Elevation: 0 mm; inbouw: no; Default Elevation: 0 mm
Pset_ManufacturerTypeInformation - Manufacturer: WISA
Materials and Finishes - Rsen_C_material_01: RSen_h2_steel_blue; Rsen_C_material_02: RSen_i4_boarding_uderlayment; Rsen_C_material_03: RSen_n6_PE_black
Text - Rsen_C_definition_02: Threaded rods; Rsen_P_c01_definition: c01_cw; Rsen_C_definition_03: Fixation plate under; Rsen_C_definition_04: Upper mounting plate; Rsen_P_c02_definition: c02_sewage; Rsen_C_definition_01: Cross section
General - Rsen_C_content_creator: WISA

# IfcFlowTerminal: xs washbasin cornerframe_wisa_built in element for washbasin, RSen_74_PF_FB_built-in element washbasin xs angle_wisa:xs washbasin cornerframe_wisa_built in element for washbasin:3970264
In: Level 1
Type - ElementType: xs washbasin cornerframe_wisa_built in element for washbasin; PredefinedType: WASHHANDBASIN; Classification: 4A(74.22) ingebouwde sanitaire voorzieningen (UniFormat); Material: RSen_i4_boarding_uderlayment, RSen_h2_steel_blue
Constraints - Default Elevation: 0 mm; Elevation: 0 mm; inbouw: no; Host: Reference Plane
Mechanical - Rsen_P_c01_fixture units: 0; CWFU: 0; WFU: 0; System Classification: Sanitary
Materials and Finishes - Rsen_C_material_02: RSen_i4_boarding_uderlayment; Rsen_C_material_01: RSen_h2_steel_blue
Text - Rsen_C_definition_01: Cross section; Rsen_C_definition_02: Threaded rods; Rsen_P_c01_definition: c01_sewage
General - Rsen_C_content_creator: WISA
Dimensions - Rsen_C_height: 1180 mm; Rsen_C_width: 380 mm; Rsen_C_depth: 200 mm; Rsen_P_c01_diameter: 50 mm; height_02: 760 mm; height_01: 556.5 mm; width_02: 230 mm
Identity Data - Rsen_C_code_STABU: 53.31; Rsen_C_type_comments: Wastafelframe; NLRS_C_revit_versie: 2014; Rsen_C_code_gtin: 8711778121096; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC011369&ArtClassVersion=3; Description: WISA XS wash basin corner frame; Rsen_C_code_ETIM: EC011369; Model: XS; Rsen_C_description: WISA XS wash basin corner frame; Rsen_C_model: XS; URL: www.wisa-sanitair.com/nl/8050452722; Manufacturer: WISA; Assembly Code: 4A(74.22); Rsen_C_code_SfB_table1: 74.22; Rsen_C_code_manufacturer_product: 8050452721; Rsen_C_code_manufacturer_gln: 8711778000001; Type Comments: Double wall/built-in element washbasin; Assembly Description: ingebouwde sanitaire voorzieningen; Mark: 1772
Phasing - Phase Created: New Construction
Other - calc_initial adjustment_height: 0 mm; Rsen_C_width_02: 230 mm; Rsen_C_height_02: 760 mm; Schedule Level: Level: Level 1; origin: 0 mm; Rsen_C_height_01: 556.5 mm; calc_initial adjustment_depth: 200 mm; calc_front wall_thickness: 3 mm
Construction - initial adjustment_depth: 200 mm; initial adjustment_height: 0 mm; front wall_thickness: 0 mm
Plumbing - sewage_diameter_50: yes; sewage_diameter_40: no
Model Properties - corner fixation set: no
Pset_ManufacturerTypeInformation - Manufacturer: WISA

# IfcFlowTerminal: xs washbasin with built-in trap_wisa_built in element for washbasin, RSen_74_PF_FB_built-in element washbasin xs with built-in trap_wisa:xs washbasin with built-in trap_wisa_built in element for washbasin:3970150
In: Level 1
Type - ElementType: xs washbasin with built-in trap_wisa_built in element for washbasin; PredefinedType: WASHHANDBASIN; Classification: 4A(74.22) ingebouwde sanitaire voorzieningen (UniFormat); Material: RSen_i4_boarding_uderlayment, RSen_h2_steel_blue
Dimensions - Rsen_C_width: 380 mm; Rsen_C_height: 1180 mm; height_01: 556.5 mm; width_02: 230 mm; height_02: 760 mm; Rsen_P_c01_diameter: 50 mm; Rsen_C_depth: 200 mm
General - Rsen_C_content_creator: WISA
Materials and Finishes - Rsen_C_material_02: RSen_i4_boarding_uderlayment; Rsen_C_material_01: RSen_h2_steel_blue
Text - Rsen_P_c01_definition: c01_sewage; Rsen_C_definition_02: Threaded rods; Rsen_C_definition_01: Cross section
Mechanical - CWFU: 0; Rsen_P_c01_fixture units: 0; WFU: 0; System Classification: Sanitary
Constraints - Default Elevation: 0 mm; Elevation: 0 mm; Host: Reference Plane; inbouw: no
Construction - initial adjustment_height: 0 mm; initial adjustment_depth: 200 mm; front wall_thickness: 0 mm
Plumbing - sewage_diameter_50: yes; sewage_diameter_40: no
Model Properties - corner fixation set: no
Other - origin: 0 mm; Rsen_C_height_02: 760 mm; calc_initial adjustment_depth: 200 mm; Rsen_C_width_02: 230 mm; calc_initial adjustment_height: 0 mm; Rsen_C_height_01: 556.5 mm; Schedule Level: Level: Level 1; calc_front wall_thickness: 3 mm
Identity Data - Mark: 1771; Rsen_C_code_STABU: 53.31; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC011369&ArtClassVersion=3; URL: www.wisa-sanitair.com/nl/8050452723; Rsen_C_code_ETIM: EC011369; Description: WISA XS wash basin frame with build-in trap; NLRS_C_revit_versie: 2014; Assembly Code: 4A(74.22); Type Comments: Double wall/built-in element washbasin; Rsen_C_code_manufacturer_gln: 8711778000001; Assembly Description: ingebouwde sanitaire voorzieningen; Rsen_C_type_comments: Double wall/built-in element washbasin; Rsen_C_description: WISA XS wastafel element met inbouwsifon; Model: XS; Manufacturer: WISA; Rsen_C_model: XS; Rsen_C_code_SfB_table1: 74.22; Rsen_C_code_manufacturer_product: 8050452723; Rsen_C_code_gtin: 8711778121102
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: WISA

# IfcFlowTerminal: xs washbasin_wisa_built in element for washbasin, RSen_74_PF_FB_built-in element washbasin xs_wisa:xs washbasin_wisa_built in element for washbasin:3970102
In: Level 1
Type - ElementType: xs washbasin_wisa_built in element for washbasin; PredefinedType: WASHHANDBASIN; Classification: 4A(74.22) ingebouwde sanitaire voorzieningen (UniFormat); Material: RSen_i4_boarding_uderlayment, RSen_h2_steel_blue
Identity Data - Mark: 1770; Type Comments: Double wall/built-in element washbasin; Rsen_C_code_manufacturer_gln: 8711778000001; Rsen_C_code_SfB_table1: 74.22; Assembly Description: ingebouwde sanitaire voorzieningen; Manufacturer: WISA; Rsen_C_description: WISA XS wastafel element; Rsen_C_code_ETIM: EC011369; Description: WISA XS wash basin frame; NLRS_C_revit_versie: 2014; URL: www.wisa-sanitair.com/nl/8050452721; Rsen_C_code_gtin: 8711778118638; Rsen_C_code_manufacturer_product: 8050452721; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC011369&ArtClassVersion=3; Assembly Code: 4A(74.22); Rsen_C_model: XS; Model: XS; Rsen_C_type_comments: Wastafelframe; Rsen_C_code_STABU: 53.31
Constraints - Elevation: 0 mm; Host: Reference Plane; inbouw: no; Default Elevation: 0 mm
Dimensions - height_01: 556.5 mm; height_02: 760 mm; width_02: 230 mm; Rsen_P_c01_diameter: 50 mm; Rsen_C_depth: 200 mm; Rsen_C_width: 380 mm; Rsen_C_height: 1180 mm
Plumbing - sewage_diameter_40: no; sewage_diameter_50: yes
Other - calc_front wall_thickness: 3 mm; Rsen_C_height_01: 556.5 mm; Rsen_C_height_02: 760 mm; origin: 0 mm; Schedule Level: Level: Level 1; calc_initial adjustment_depth: 200 mm; Rsen_C_width_02: 230 mm; calc_initial adjustment_height: 0 mm
Mechanical - System Classification: Sanitary; WFU: 0; Rsen_P_c01_fixture units: 0; CWFU: 0
Construction - initial adjustment_depth: 200 mm; initial adjustment_height: 0 mm; front wall_thickness: 0 mm
Model Properties - corner fixation set: no
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: WISA
General - Rsen_C_content_creator: WISA
Materials and Finishes - Rsen_C_material_01: RSen_h2_steel_blue; Rsen_C_material_02: RSen_i4_boarding_uderlayment
Text - Rsen_P_c01_definition: c01_sewage; Rsen_C_definition_02: Threaded rods; Rsen_C_definition_01: Cross section

# IfcFlowTerminal: xs wc cornerframe 90/100mm_wisa_built in element, RSen_74_PF_FB_built in element xs wc frame corner ø100mm_wisa:xs wc cornerframe 90/100mm_wisa_built in element:3948170
In: Level 1
Type - ElementType: xs wc cornerframe 90/100mm_wisa_built in element; PredefinedType: CISTERN; Classification: 4A(74.22) ingebouwde sanitaire voorzieningen (UniFormat); Material: RSen_h2_steel_blue, RSen_n6_PEXa_yellow, RSen_n6_PEXa_white
Dimensions - Rsen_C_depth: 200 mm; Rsen_P_c02_diameter: 100 mm; Rsen_P_c02_angle: 0 deg; rs_C_guest_mounting height: 230 mm; Rsen_C_width: 380 mm; Rsen_C_height: 1180 mm; Rsen_P_c01_diameter: 15 mm
Other - cw_angle: 90 deg; calc_sewage: 88 mm; calc_sewage_length: 222 mm; calc_threaded rod: 230 mm; cw_depth: 73 mm; calc_front wall_thickness: 3 mm; Schedule Level: Level: Level 1; cw_height: 85 mm; calc_dist_connection_angle: 88 mm; calc_sewage_distance: 88 mm; calc_initial adjustment_depth: 200 mm; calc_initial adjustment_height: 0 mm; origin: 0 mm
Construction - front wall_thickness: 0 mm; threaded rod_180: no; initial adjustment_height: 0 mm; initial adjustment_depth: 200 mm; threaded rod_230: yes
Phasing - Phase Created: New Construction
Identity Data - Mark: 1745; Assembly Description: ingebouwde sanitaire voorzieningen; Rsen_C_description: WISA XS WC frame corner 90/100 mm; Rsen_C_code_STABU: 53.31; Rsen_C_code_gtin: 8711778121072; Manufacturer: WISA; Rsen_C_model: XS; Rsen_C_code_ETIM: EC010145; Rsen_C_code_manufacturer_gln: 8711778000001; Description: WISA XS WC frame corner 90/100 mm; Assembly Code: 4A(74.22); Rsen_C_code_manufacturer_product: 8050452704; Model: XS; Rsen_C_type_comments: Built-in element wall-hung closet with flushing reservoir; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC010145&ArtClassVersion=4; NLRS_C_revit_versie: 2014; Rsen_C_code_SfB_table1: 74.22; Type Comments: Built-in element wall-hung closet with flushing reservoir
Plumbing - sewage_length: 222 mm; cw_connection_behind: no; sewage_diameter_100: yes; sewage_angle: 0 deg; cw_connection_above: yes; sewage_initial adjustment depth: 0 mm; sewage_diameter_90: no
Mechanical - System Classification: Sanitary,Domestic Cold Water; CWFU: 0; Rsen_P_c01_fixture units: 0; WFU: 0; Rsen_P_c02_fixture units: 0
Constraints - Host: Reference Plane; Elevation: 0 mm; inbouw: no; Default Elevation: 0 mm
Model Properties - control panel: RSen_74_PF_FB_control panel_wisa: ▼ choose
Pset_ManufacturerTypeInformation - Manufacturer: WISA
Mechanical - Flow - flush_volume: 0.26486 ft3
Text - water connection: G 1/2; Rsen_P_c01_definition: c01_cw; Rsen_P_c02_definition: c02_sewage
Materials and Finishes - Rsen_C_material_01: RSen_h2_steel_blue
General - Rsen_C_content_creator: WISA

# IfcFlowTerminal: xs wc cornerframe_wisa_built in element, RSen_74_PF_FB_built in element xs wc frame corner_wisa:xs wc cornerframe_wisa_built in element:3948138
In: Level 1
Type - ElementType: xs wc cornerframe_wisa_built in element; PredefinedType: CISTERN; Classification: 4A(74.22) ingebouwde sanitaire voorzieningen (UniFormat); Material: RSen_h2_steel_blue, RSen_n6_PEXa_yellow, RSen_n6_PEXa_white
Other - cw_depth: 73 mm; calc_dist_connection_angle: 88 mm; calc_sewage_length: 222 mm; origin: 0 mm; calc_initial adjustment_depth: 200 mm; Schedule Level: Level: Level 1; calc_sewage: 88 mm; cw_angle: 90 deg; calc_threaded rod: 230 mm; calc_front wall_thickness: 3 mm; calc_initial adjustment_height: 0 mm; calc_sewage_distance: 88 mm; cw_height: 85 mm
Plumbing - sewage_diameter_110: yes; cw_connection_above: yes; sewage_angle: 0 deg; sewage_length: 222 mm; sewage_diameter_90: no; sewage_initial adjustment depth: 0 mm; cw_connection_behind: no
Identity Data - Mark: 1743; Rsen_C_code_manufacturer_gln: 8711778000001; Description: WISA XS WC frame corner 90/110 mm; Rsen_C_code_manufacturer_product: 8050452703; Rsen_C_code_STABU: 53.31; Assembly Code: 4A(74.22); Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC010145&ArtClassVersion=4; Assembly Description: ingebouwde sanitaire voorzieningen; Rsen_C_code_gtin: 8711778121065; Rsen_C_description: WISA XS WC frame corner 90/110 mm; Rsen_C_code_SfB_table1: 74.22; Model: XS; Rsen_C_code_ETIM: EC010145; NLRS_C_revit_versie: 2014; Rsen_C_model: XS; Rsen_C_type_comments: Inbouwreservoir; Type Comments: Built-in element wall-hung closet with flushing reservoir; Manufacturer: WISA; URL: www.wisa-sanitair.com/nl/8050452703
Construction - threaded rod_180: no; front wall_thickness: 0 mm; initial adjustment_depth: 200 mm; initial adjustment_height: 0 mm; threaded rod_230: yes
Model Properties - control panel: RSen_74_PF_FB_control panel_wisa: ▼ choose
Phasing - Phase Created: New Construction
Dimensions - Rsen_P_c02_angle: 0 deg; Rsen_C_depth: 200 mm; Rsen_P_c02_diameter: 110 mm; Rsen_C_width: 380 mm; rs_C_guest_mounting height: 230 mm; Rsen_C_height: 1180 mm; Rsen_P_c01_diameter: 15 mm
Mechanical - System Classification: Sanitary,Domestic Cold Water; WFU: 0; Rsen_P_c01_fixture units: 0; Rsen_P_c02_fixture units: 0; CWFU: 0
Constraints - Elevation: 0 mm; inbouw: no; Host: Reference Plane; Default Elevation: 0 mm
Pset_ManufacturerTypeInformation - Manufacturer: WISA
Materials and Finishes - Rsen_C_material_01: RSen_h2_steel_blue
Mechanical - Flow - flush_volume: 0.26486 ft3
Text - water connection: G 1/2; Rsen_P_c02_definition: c02_sewage; Rsen_P_c01_definition: c01_cw
General - Rsen_C_content_creator: WISA

# IfcFlowTerminal: xs wc frame 90/100mm_wisa_built in element, RSen_74_PF_FB_built in element xs wc frame ø100mm_wisa:xs wc frame 90/100mm_wisa_built in element:3948050
In: Level 1
Type - ElementType: xs wc frame 90/100mm_wisa_built in element; PredefinedType: CISTERN; Classification: 4A(74.22) ingebouwde sanitaire voorzieningen (UniFormat); Material: RSen_h2_steel_blue, RSen_n6_PEXa_yellow, RSen_n6_PEXa_white
Plumbing - sewage_length: 222 mm; sewage_angle: 0 deg; cw_connection_above: yes; sewage_diameter_100: yes; cw_connection_behind: no; sewage_diameter_90: no; sewage_initial adjustment depth: 0 mm
Other - calc_sewage_length: 222 mm; calc_initial adjustment_depth: 200 mm; calc_sewage_distance: 88 mm; calc_sewage: 88 mm; Schedule Level: Level: Level 1; calc_threaded rod: 230 mm; cw_height: 85 mm; calc_dist_connection_angle: 88 mm; cw_depth: 73 mm; origin: 0 mm; cw_angle: 90 deg; calc_initial adjustment_height: 0 mm; calc_front wall_thickness: 3 mm
Construction - initial adjustment_depth: 200 mm; front wall_thickness: 0 mm; threaded rod_180: no; initial adjustment_height: 0 mm; threaded rod_230: yes
Mechanical - System Classification: Sanitary,Domestic Cold Water; CWFU: 0; Rsen_P_c01_fixture units: 0; Rsen_P_c02_fixture units: 0; WFU: 0
Model Properties - control panel: RSen_74_PF_FB_control panel_wisa: ▼ choose; corner fixation set: no
Phasing - Phase Created: New Construction
Dimensions - Rsen_P_c02_diameter: 100 mm; Rsen_P_c02_angle: 0 deg; Rsen_C_depth: 200 mm; Rsen_P_c01_diameter: 15 mm; Rsen_C_width: 380 mm; Rsen_C_height: 1180 mm; rs_C_guest_mounting height: 230 mm
Constraints - inbouw: no; Host: Reference Plane; Elevation: 0 mm; Default Elevation: 0 mm
Identity Data - Mark: 1741; Assembly Code: 4A(74.22); Type Comments: Built-in element wall-hung closet with flushing reservoir; Rsen_C_code_STABU: 53.31; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC010145&ArtClassVersion=4; Rsen_C_code_gtin: 8711778121058; Rsen_C_description: WISA XS WC front Ø100mm; Assembly Description: ingebouwde sanitaire voorzieningen; Rsen_C_code_ETIM: EC010145; Manufacturer: WISA; Rsen_C_code_SfB_table1: 74.22; Model: XS; Rsen_C_code_manufacturer_gln: 8711778000001; Rsen_C_type_comments: Inbouwreservoir; NLRS_C_revit_versie: 2014; Rsen_C_code_manufacturer_product: 8050452702; Rsen_C_model: XS; Description: WISA XS WC frame 90/100 mm
Pset_ManufacturerTypeInformation - Manufacturer: WISA
Text - Rsen_P_c01_definition: c01_cw; water connection: G 1/2; Rsen_P_c02_definition: c02_sewage
General - Rsen_C_content_creator: WISA
Materials and Finishes - Rsen_C_material_01: RSen_h2_steel_blue
Mechanical - Flow - flush_volume: 0.26486 ft3

# IfcFlowTerminal: xs wc frame self supporting 90/100mm_wisa_built in element, RSen_74_PF_FB_built in element xs wc frame self supporting ø100mm_wisa:xs wc frame self supporting 90/100mm_wisa_built in element:3948335
In: Level 1
Type - ElementType: xs wc frame self supporting 90/100mm_wisa_built in element; PredefinedType: CISTERN; Classification: 4A(74.22) ingebouwde sanitaire voorzieningen (UniFormat); Material: RSen_h2_steel_blue, RSen_n6_PEXa_yellow, RSen_n6_PEXa_white
Other - cw_depth: 73 mm; origin: 0 mm; cw_height: 85 mm; calc_initial adjustment_height: 0 mm; calc_sewage_length: 222 mm; calc_sewage_distance: 105 mm; cw_angle: 90 deg; calc_front wall_thickness: 3 mm; Schedule Level: Level: Level 1; calc_dist_connection_angle: 88 mm; calc_initial adjustment_depth: 210 mm; calc_threaded rod: 230 mm
Construction - threaded rod_230: yes; initial adjustment_depth: 210 mm; threaded rod_180: no; initial adjustment_height: 0 mm; front wall_thickness: 0 mm
Plumbing - cw_connection_above: yes; sewage_diameter_90: no; cw_connection_behind: no; sewage_length: 222 mm; sewage_diameter_100: yes; sewage_angle: 0 deg
Constraints - inbouw: no; Elevation: 0 mm; Host: Reference Plane; Default Elevation: 0 mm
Identity Data - Mark: 1749; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC010145&ArtClassVersion=4; Assembly Description: ingebouwde sanitaire voorzieningen; Rsen_C_code_ETIM: EC010145; Rsen_C_code_STABU: 53.31; Assembly Code: 4A(74.22); Model: XS; Rsen_C_description: WISA XS WC SSF/autoportant front Ø100mm; Rsen_C_type_comments: Built-in element wall-hung closet with flushing reservoir; Rsen_C_code_manufacturer_product: 8050452732; Rsen_C_code_manufacturer_gln: 8711778000001; Manufacturer: WISA; Type Comments: Built-in element wall-hung closet with flushing reservoir; Description: WISA XS WC frame self supporting 90/100 mm; Rsen_C_code_gtin: 8711778121133; Rsen_C_model: XS; Rsen_C_code_SfB_table1: 74.22; NLRS_C_revit_versie: 2014
Phasing - Phase Created: New Construction
Mechanical - System Classification: Sanitary,Domestic Cold Water; Rsen_P_c02_fixture units: 0; Rsen_P_c01_fixture units: 0; WFU: 0; CWFU: 0
Dimensions - Rsen_P_c02_diameter: 100 mm; Rsen_P_c02_angle: 0 deg; Rsen_C_depth: 210 mm; Rsen_P_c01_diameter: 15 mm; Rsen_C_width: 380 mm; Rsen_C_height: 1180 mm; rs_C_guest_mounting height: 230 mm
Model Properties - control panel: RSen_74_PF_FB_control panel_wisa: ▼ choose
Pset_ManufacturerTypeInformation - Manufacturer: WISA
Materials and Finishes - Rsen_C_material_01: RSen_h2_steel_blue
Mechanical - Flow - flush_volume: 0.26486 ft3
Text - Rsen_P_c01_definition: c01_cw; Rsen_P_c02_definition: c02_sewage; water connection: G 1/2
General - Rsen_C_content_creator: WISA

# IfcFlowTerminal: xs wc frame self supporting_wisa_built in element, RSen_74_PF_FB_built in element xs wc frame self supporting_wisa:xs wc frame self supporting_wisa_built in element:3948263
In: Level 1
Type - ElementType: xs wc frame self supporting_wisa_built in element; PredefinedType: CISTERN; Classification: 4A(74.22) ingebouwde sanitaire voorzieningen (UniFormat); Material: RSen_h2_steel_blue, RSen_n6_PEXa_yellow, RSen_n6_PEXa_white
Construction - initial adjustment_depth: 210 mm; front wall_thickness: 0 mm; threaded rod_180: no; initial adjustment_height: 0 mm; threaded rod_230: yes
Other - cw_depth: 73 mm; Schedule Level: Level: Level 1; calc_sewage_distance: 105 mm; calc_initial adjustment_depth: 210 mm; calc_initial adjustment_height: 0 mm; cw_angle: 90 deg; calc_front wall_thickness: 3 mm; cw_height: 85 mm; calc_dist_connection_angle: 88 mm; origin: 0 mm; calc_sewage_length: 222 mm; calc_threaded rod: 230 mm
Model Properties - control panel: RSen_74_PF_FB_control panel_wisa: ▼ choose
Dimensions - Rsen_C_depth: 210 mm; Rsen_P_c02_diameter: 110 mm; Rsen_P_c02_angle: 0 deg; Rsen_C_height: 1180 mm; Rsen_P_c01_diameter: 15 mm; rs_C_guest_mounting height: 230 mm; Rsen_C_width: 380 mm
Phasing - Phase Created: New Construction
Mechanical - System Classification: Sanitary,Domestic Cold Water; WFU: 0; CWFU: 0; Rsen_P_c01_fixture units: 0; Rsen_P_c02_fixture units: 0
Constraints - inbouw: no; Host: Reference Plane; Elevation: 0 mm; Default Elevation: 0 mm
Identity Data - Mark: 1747; Rsen_C_description: WISA XS WC SSF/autoportant front; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC010145&ArtClassVersion=4; Rsen_C_code_gtin: 8711778121126; Assembly Code: 4A(74.22); URL: www.wisa-sanitair.com/nl/8050452731; Manufacturer: WISA; Assembly Description: ingebouwde sanitaire voorzieningen; Rsen_C_type_comments: Built-in element wall-hung closet with flushing reservoir; Rsen_C_code_ETIM: EC010145; Rsen_C_code_STABU: 53.31; Rsen_C_code_SfB_table1: 74.22; Rsen_C_code_manufacturer_gln: 8711778000001; Description: WISA XS WC frame self supporting 90/110 mm; Model: XS; Rsen_C_code_manufacturer_product: 8050452731; Type Comments: Built-in element wall-hung closet with flushing reservoir; NLRS_C_revit_versie: 2014; Rsen_C_model: XS
Plumbing - sewage_length: 222 mm; sewage_angle: 0 deg; cw_connection_behind: no; sewage_diameter_90: no; cw_connection_above: yes; sewage_diameter_110: yes
Pset_ManufacturerTypeInformation - Manufacturer: WISA
Mechanical - Flow - flush_volume: 0.26486 ft3
Text - water connection: G 1/2; Rsen_P_c02_definition: c02_sewage; Rsen_P_c01_definition: c01_cw
Materials and Finishes - Rsen_C_material_01: RSen_h2_steel_blue
General - Rsen_C_content_creator: WISA

# IfcFlowTerminal: xs wc frame_wisa_built in element, RSen_74_PF_FB_built in element xs wc frame_wisa:xs wc frame_wisa_built in element:3947873
In: Level 1
Type - ElementType: xs wc frame_wisa_built in element; PredefinedType: CISTERN; Classification: 4A(74.22) ingebouwde sanitaire voorzieningen (UniFormat); Material: RSen_h2_steel_blue, RSen_n6_PEXa_yellow, RSen_n6_PEXa_white
Plumbing - cw_connection_behind: no; cw_connection_above: yes; sewage_angle: 0 deg; sewage_diameter_90: no; sewage_diameter_110: yes; sewage_initial adjustment depth: 0 mm; sewage_length: 222 mm
Model Properties - corner fixation set: no; control panel: RSen_74_PF_FB_control panel_wisa: ▼ choose
Construction - front wall_thickness: 0 mm; initial adjustment_height: 0 mm; initial adjustment_depth: 200 mm; threaded rod_230: yes; threaded rod_180: no
Other - calc_sewage: 88 mm; calc_initial adjustment_depth: 200 mm; calc_front wall_thickness: 3 mm; calc_dist_connection_angle: 88 mm; calc_threaded rod: 230 mm; Schedule Level: Level: Level 1; calc_sewage_length: 222 mm; cw_depth: 73 mm; calc_sewage_distance: 88 mm; calc_initial adjustment_height: 0 mm; cw_angle: 90 deg; cw_height: 85 mm; origin: 0 mm
Mechanical - System Classification: Sanitary,Domestic Cold Water; Rsen_P_c02_fixture units: 0; WFU: 0; Rsen_P_c01_fixture units: 0; CWFU: 0
Dimensions - Rsen_P_c02_diameter: 110 mm; Rsen_P_c02_angle: 0 deg; Rsen_C_depth: 200 mm; rs_C_guest_mounting height: 230 mm; Rsen_C_width: 380 mm; Rsen_P_c01_diameter: 15 mm; Rsen_C_height: 1180 mm
Identity Data - Mark: 1739; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC010145&ArtClassVersion=4; Model: XS; Description: WISA XS WC frame 90/110 mm; Rsen_C_type_comments: Built-in element wall-hung closet with flushing reservoir; Rsen_C_code_manufacturer_product: 8050452701; NLRS_C_revit_versie: 2014; Type Comments: Built-in element wall-hung closet with flushing reservoir; Rsen_C_code_SfB_table1: 74.22; Rsen_C_code_ETIM: EC010145; Manufacturer: WISA; Rsen_C_code_gtin: 8711778118614; Rsen_C_model: XS; Assembly Description: ingebouwde sanitaire voorzieningen; Rsen_C_description: WISA XS WC front; Rsen_C_code_STABU: 53.31; Assembly Code: 4A(74.22); URL: www.wisa-sanitair.com/nl/8050452701; Rsen_C_code_manufacturer_gln: 8711778000001
Constraints - Elevation: 0 mm; inbouw: no; Host: Reference Plane; Default Elevation: 0 mm
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: WISA
Text - water connection: G 1/2; Rsen_P_c01_definition: c01_cw; Rsen_P_c02_definition: c02_sewage
General - Rsen_C_content_creator: WISA
Materials and Finishes - Rsen_C_material_01: RSen_h2_steel_blue
Mechanical - Flow - flush_volume: 0.26486 ft3

# IfcFlowTerminal: xs wc t frame 90/110mm_wisa_built in element, RSen_74_PF_FB_built in element xs wc t_wisa:xs wc t frame 90/110mm_wisa_built in element:3948944
In: Level 1
Type - ElementType: xs wc t frame 90/110mm_wisa_built in element; PredefinedType: CISTERN; Classification: 4A(74.22) ingebouwde sanitaire voorzieningen (UniFormat); Material: RSen_h2_steel_blue, RSen_n6_PEXa_yellow, RSen_n6_PEXa_white
Phasing - Phase Created: New Construction
Construction - front wall_thickness: 0 mm; threaded rod_180: no; threaded rod_230: yes; initial adjustment_depth: 200 mm; initial adjustment_height: 0 mm
Other - Schedule Level: Level: Level 1; calc_front wall_thickness: 3 mm; calc_threaded rod: 230 mm; origin: 0 mm; calc_initial adjustment_depth: 200 mm; cw_depth: 73 mm; calc_sewage: 88 mm; cw_angle: 90 deg; calc_sewage_distance: 88 mm; calc_sewage_length: 222 mm; calc_initial adjustment_height: 0 mm; cw_height: 85 mm; calc_dist_connection_angle: 88 mm
Plumbing - sewage_initial adjustment depth: 0 mm; cw_connection_above: yes; sewage_diameter_90: no; sewage_length: 222 mm; sewage_angle: 0 deg; sewage_diameter_100: yes; cw_connection_behind: no
