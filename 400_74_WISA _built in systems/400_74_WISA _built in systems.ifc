Properties of the parts of a building model (IFC2X3), part 2 of 2

# IfcFlowTerminal: xs wc t frame 90/110mm_wisa_built in element, RSen_74_PF_FB_built in element xs wc t_wisa:xs wc t frame 90/110mm_wisa_built in element:3948944
Identity Data - Mark: 1761; Assembly Description: ingebouwde sanitaire voorzieningen; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC010145&ArtClassVersion=4; Assembly Code: 4A(74.22); Rsen_C_code_manufacturer_gln: 8711778000001; Description: WISA XS WC T 90/100 mm; Manufacturer: WISA; Rsen_C_code_manufacturer_product: 8050452705; Rsen_C_code_gtin: 8711778121089; Rsen_C_description: WISA XS WC T 90/100mm; Type Comments: Built-in element wall-hung closet with flushing reservoir; Rsen_C_model: XS; Rsen_C_type_comments: Inbouwreservoir; Rsen_C_code_STABU: 53.31; Rsen_C_code_ETIM: EC010145; Rsen_C_code_SfB_table1: 74.22; NLRS_C_revit_versie: 2014; Model: XS
Constraints - Elevation: 0 mm; Host: Reference Plane; inbouw: no; Default Elevation: 0 mm
Model Properties - corner fixation set: no; control panel: RSen_74_PF_FB_control panel_wisa: ▼ choose
Dimensions - Rsen_P_c02_angle: 0 deg; Rsen_C_depth: 200 mm; Rsen_P_c02_diameter: 100 mm; Rsen_P_c01_diameter: 15 mm; Rsen_C_width: 380 mm; rs_C_guest_mounting height: 230 mm; Rsen_C_height: 1180 mm
Mechanical - System Classification: Sanitary,Domestic Cold Water; Rsen_P_c01_fixture units: 0; CWFU: 0; Rsen_P_c02_fixture units: 0; WFU: 0
Pset_ManufacturerTypeInformation - Manufacturer: WISA
Mechanical - Flow - flush_volume: 0.26486 ft3
Text - Rsen_P_c01_definition: c01_cw; water connection: G 1/2; Rsen_P_c02_definition: c02_sewage
Materials and Finishes - Rsen_C_material_01: RSen_h2_steel_blue
General - Rsen_C_content_creator: WISA

# IfcFlowTerminal: xs wc vario 90/100mm_wisa_built in element, RSen_74_PF_FB_built in element xs wc vario ø100mm_wisa:xs wc vario 90/100mm_wisa_built in element:3948648
In: Level 1
Type - ElementType: xs wc vario 90/100mm_wisa_built in element; PredefinedType: CISTERN; Classification: 4A(74.22) ingebouwde sanitaire voorzieningen (UniFormat); Material: RSen_h2_steel_blue, RSen_n6_PEXa_yellow, RSen_n6_PEXa_white
Plumbing - sewage_initial adjustment depth: 0 mm; cw_connection_above: yes; sewage_left: no; sewage_angle: 0 deg; sewage_diameter_90: no; sewage_diameter_100: yes; cw_connection_behind: no; sewage_length: 222 mm; sewage_position: 1; sewage_right: no; sewage_under: yes
Identity Data - Mark: 1757; Assembly Code: 4A(74.22); Rsen_C_code_gtin: 8711778121171; Rsen_C_description: WISA XS Vario 90/100 mm; Rsen_C_model: XS; Manufacturer: WISA; Assembly Description: ingebouwde sanitaire voorzieningen; Type Comments: Built-in element wall-hung closet with flushing reservoir; NLRS_C_revit_versie: 2014; Rsen_C_code_SfB_table1: 74.22; Rsen_C_type_comments: Built-in element wall-hung closet with flushing reservoir; Rsen_C_code_manufacturer_gln: 8711778000001; Rsen_C_code_manufacturer_product: 8050452736; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC010145&ArtClassVersion=4; Model: XS; Rsen_C_code_ETIM: EC010145; Description: WISA XS Vario 90/100 mm; Rsen_C_code_STABU: 53.31
Construction - front wall_thickness: 0 mm; initial adjustment_height: 0 mm; threaded rod_230: yes; threaded rod_180: no; wall closet_height: 200 mm; initial adjustment_depth: 0 mm
Constraints - Host: Reference Plane; Elevation: 0 mm; inbouw: no; Default Elevation: 0 mm
Dimensions - Rsen_P_c02_diameter: 100 mm; Rsen_C_depth: 160 mm; Rsen_P_c02_angle: 0 deg; Rsen_C_width: 380 mm; Rsen_C_height: 1300 mm; rs_C_guest_mounting height: 230 mm; Rsen_P_c01_diameter: 15 mm
Other - Schedule Level: Level: Level 1; calc_front wall_thickness: 3 mm; cw_depth: 73 mm; calc_sewage: 88 mm; cw_angle: 90 deg; calc_sewage_width: 255 mm; calc_sewage_length: 222 mm; calc_dist_connection_angle: 88 mm; calc_sewage_distance: 88 mm; calc_wall closet_height: 330 mm; calc_initial adjustment_height: 0 mm; calc_initial adjustment_depth: 160 mm; cw_height: 85 mm; calc_threaded rod: 230 mm; origin: 0 mm; calc_sewage_height: 0 mm
Mechanical - System Classification: Domestic Cold Water,Sanitary; CWFU: 0; Rsen_P_c01_fixture units: 0; Rsen_P_c02_fixture units: 0; WFU: 0
Model Properties - corner fixation set: no; control panel: RSen_74_PF_FB_control panel_wisa: ▼ choose
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: WISA
Materials and Finishes - Rsen_C_material_02: RSen_n6_PEXa_white; Rsen_C_material_01: RSen_h2_steel_blue
Text - water connection: G 1/2; Rsen_P_c01_definition: c01_cw; Rsen_P_c02_definition: c02_sewage
General - Rsen_C_content_creator: WISA
Mechanical - Flow - flush_volume: 0.26486 ft3

# IfcFlowTerminal: xs wc vario with support plates_wisa_built in element, RSen_74_PF_FB_built in element xs wc vario with support plates_wisa:xs wc vario with support plates_wisa_built in element:3948778
In: Level 1
Type - ElementType: xs wc vario with support plates_wisa_built in element; PredefinedType: CISTERN; Classification: 4A(74.22) ingebouwde sanitaire voorzieningen (UniFormat); Material: RSen_h2_steel_blue, RSen_n6_PEXa_yellow, RSen_n6_PEXa_white, RSen_i4_boarding_uderlayment
Constraints - Host: Reference Plane; inbouw: no; Elevation: 0 mm; Default Elevation: 0 mm
Other - calc_sewage_length: 222 mm; calc_initial adjustment_depth: 160 mm; calc_sewage: 88 mm; calc_sewage_distance: 88 mm; origin: 0 mm; calc_front wall_thickness: 3 mm; calc_sewage_height: 0 mm; calc_threaded rod: 230 mm; cw_height: 85 mm; Schedule Level: Level: Level 1; calc_wall closet_height: 330 mm; calc_initial adjustment_height: 0 mm; calc_sewage_width: 255 mm; cw_depth: 73 mm; calc_dist_connection_angle: 88 mm; cw_angle: 90 deg
Phasing - Phase Created: New Construction
Plumbing - sewage_left: no; sewage_diameter_110: yes; sewage_initial adjustment depth: 0 mm; sewage_position: 1; cw_connection_above: yes; cw_connection_behind: no; sewage_length: 222 mm; sewage_angle: 0 deg; sewage_diameter_90: no; sewage_under: yes; sewage_right: no
Construction - threaded rod_230: yes; front wall_thickness: 0 mm; initial adjustment_height: 0 mm; initial adjustment_depth: 0 mm; threaded rod_180: no; wall closet_height: 200 mm
Mechanical - System Classification: Domestic Cold Water,Sanitary; WFU: 0; CWFU: 0; Rsen_P_c02_fixture units: 0; Rsen_P_c01_fixture units: 0
Identity Data - Mark: 1759; Assembly Code: 4A(74.22); Model: XS; Rsen_C_code_ETIM: EC010145; URL: www.wisa-sanitair.com/nl/8050452738; Rsen_C_code_gtin: 8711778163218; Rsen_C_model: XS; Assembly Description: ingebouwde sanitaire voorzieningen; Rsen_C_code_SfB_table1: 74.22; NLRS_C_revit_versie: 2014; Rsen_C_code_manufacturer_gln: 8711778000001; Rsen_C_description: WISA XS WC Vario met steunbeugelelementen; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC010145&ArtClassVersion=4; Manufacturer: WISA; Rsen_C_code_manufacturer_product: 8050452738; Type Comments: Built-in element wall-hung closet with flushing reservoir; Description: WISA XS Vario with support plates; Rsen_C_type_comments: Built-in element wall-hung closet with flushing reservoir; Rsen_C_code_STABU: 53.31
Dimensions - Rsen_P_c02_diameter: 110 mm; Rsen_P_c02_angle: 0 deg; Rsen_C_depth: 160 mm; rs_C_guest_mounting height: 230 mm; Rsen_C_height: 1300 mm; Rsen_P_c01_diameter: 15 mm; Rsen_C_width: 890 mm
Model Properties - control panel: RSen_74_PF_FB_control panel_wisa: ▼ choose
Pset_ManufacturerTypeInformation - Manufacturer: WISA
General - Rsen_C_content_creator: WISA
Materials and Finishes - Rsen_C_material_01: RSen_h2_steel_blue; Rsen_C_material_02: RSen_n6_PEXa_white; Rsen_C_material_03: RSen_i4_boarding_uderlayment
Text - Rsen_P_c02_definition: c02_sewage; water connection: G 1/2; Rsen_P_c01_definition: c01_cw
Mechanical - Flow - flush_volume: 0.26486 ft3

# IfcFlowTerminal: xs wc vario_wisa_built in element, RSen_74_PF_FB_built in element xs wc vario_wisa:xs wc vario_wisa_built in element:3948587
In: Level 1
Type - ElementType: xs wc vario_wisa_built in element; PredefinedType: USERDEFINED; Classification: 4A(74.22) ingebouwde sanitaire voorzieningen (UniFormat); Material: RSen_h2_steel_blue, RSen_n6_PEXa_yellow, RSen_n6_PEXa_white
Plumbing - sewage_right: no; sewage_length: 222 mm; sewage_under: yes; sewage_diameter_90: no; sewage_left: no; cw_connection_behind: no; sewage_diameter_110: yes; sewage_initial adjustment depth: 0 mm; sewage_angle: 0 deg; sewage_position: 1; cw_connection_above: yes
Other - cw_angle: 90 deg; calc_front wall_thickness: 3 mm; calc_sewage_height: 0 mm; origin: 0 mm; cw_height: 85 mm; calc_sewage: 88 mm; calc_sewage_distance: 88 mm; calc_initial adjustment_depth: 160 mm; calc_threaded rod: 230 mm; cw_depth: 73 mm; calc_initial adjustment_height: 0 mm; calc_sewage_length: 222 mm; calc_sewage_width: 255 mm; Schedule Level: Level: Level 1; calc_dist_connection_angle: 88 mm; calc_wall closet_height: 330 mm
Dimensions - Rsen_C_depth: 160 mm; Rsen_P_c02_diameter: 110 mm; Rsen_P_c02_angle: 0 deg; Rsen_P_c01_diameter: 15 mm; rs_C_guest_mounting height: 230 mm; Rsen_C_height: 1300 mm; Rsen_C_width: 380 mm
Phasing - Phase Created: New Construction
Constraints - Host: Reference Plane; inbouw: no; Elevation: 0 mm; Default Elevation: 0 mm
Construction - wall closet_height: 200 mm; threaded rod_230: yes; front wall_thickness: 0 mm; threaded rod_180: no; initial adjustment_depth: 0 mm; initial adjustment_height: 0 mm
Mechanical - System Classification: Domestic Cold Water,Sanitary; CWFU: 0; Rsen_P_c02_fixture units: 0; Rsen_P_c01_fixture units: 0; WFU: 0
Model Properties - corner fixation set: no; control panel: RSen_74_PF_FB_control panel_wisa: ▼ choose
Identity Data - Mark: 1755; Description: WISA XS Vario 90/110 mm; Rsen_C_code_gtin: 8711778121164; Rsen_C_model: XS; Assembly Description: ingebouwde sanitaire voorzieningen; Rsen_C_description: WISA XS WC Vario; Rsen_C_code_manufacturer_gln: 8711778000001; Type Comments: Built-in element wall-hung closet with flushing reservoir; NLRS_C_revit_versie: 2014; Rsen_C_code_SfB_table1: 74.22; Assembly Code: 4A(74.22); Rsen_C_code_manufacturer_product: 8050452735; Rsen_C_type_comments: Inbouwreservoir; URL: www.wisa-sanitair.com/nl/8050452735; Model: XS; Rsen_C_code_ETIM: EC010145; Rsen_C_code_STABU: 53.31; Manufacturer: WISA; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC010145&ArtClassVersion=4
Pset_ManufacturerTypeInformation - Manufacturer: WISA
Text - water connection: G 1/2; Rsen_P_c01_definition: c01_cw; Rsen_P_c02_definition: c02_sewage
Mechanical - Flow - flush_volume: 0.26486 ft3
Materials and Finishes - Rsen_C_material_02: RSen_n6_PEXa_white; Rsen_C_material_01: RSen_h2_steel_blue
General - Rsen_C_content_creator: WISA

# IfcFlowTerminal: xt wc frame 112cm_wisa_built in element, RSen_74_PF_FB_built in element xt wc frame 112cm_wisa:xt wc frame 112cm_wisa_built in element:3992985
In: Level 1
Type - ElementType: xt wc frame 112cm_wisa_built in element; PredefinedType: CISTERN; Classification: 4A(74.22) ingebouwde sanitaire voorzieningen (UniFormat); Material: RSen_h2_steel_blue, RSen_n6_PEXa_white
Text - water connection: G 1/2 left; Rsen_P_c02_definition: c02_sewage; Rsen_P_c01_definition: c01_cw
General - Rsen_C_content_creator: WISA
Dimensions - rs_C_guest_mounting height: 230 mm; Rsen_C_width: 380 mm; Rsen_C_height: 1120 mm; Rsen_P_c01_diameter: 15 mm; Rsen_P_c02_diameter: 110 mm; Rsen_C_depth: 200 mm; Rsen_P_c02_angle: 0 deg
Mechanical - Flow - flush_volume: 0.26486 ft3
Constraints - Default Elevation: 0 mm; inbouw: no; Elevation: 0 mm; Host: Reference Plane
Mechanical - Rsen_P_c01_fixture units: 0; Rsen_P_c02_fixture units: 0; WFU: 0; CWFU: 0; System Classification: Sanitary,Domestic Cold Water
Materials and Finishes - Rsen_C_material_01: RSen_h2_steel_blue
Identity Data - Description: WISA XT WC front 112 cm; Rsen_C_code_gtin: 8711778169111; Rsen_C_code_ETIM: EC010145; Assembly Code: 4A(74.22); URL: www.wisa-sanitair.com/nl/8050453004; Rsen_C_code_manufacturer_gln: 8711778000001; Rsen_C_type_comments: Built-in element wall-hung closet with flushing reservoir; NLRS_C_revit_versie: 2014; Model: XT; Rsen_C_code_SfB_table1: 74.22; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC010145&ArtClassVersion=4; Rsen_C_model: XT; Manufacturer: WISA; Type Comments: Built-in element wall-hung closet with flushing reservoir; Rsen_C_code_manufacturer_product: 8050453004; Rsen_C_code_STABU: 53.31; Assembly Description: ingebouwde sanitaire voorzieningen; Rsen_C_description: WISA XT WC front 112 cm; Mark: 1783
Other - origin: 0 mm; calc_initial adjustment_height: 0 mm; Schedule Level: Level: Level 1; calc_sewage: 88 mm; calc_front wall_thickness: 3 mm; calc_sewage_length: 222 mm; calc_initial adjustment_depth: 200 mm; calc_sewage_distance: 88 mm; calc_threaded rod: 230 mm; calc_dist_connection_angle: 88 mm
Model Properties - corner fixation set: no; control panel: RSen_74_PF_FB_control panel xt_wisa: ▼ choose
Construction - front wall_thickness: 0 mm; initial adjustment_depth: 200 mm; initial adjustment_height: 0 mm; threaded rod_180: no; threaded rod_230: yes
Plumbing - sewage_angle: 0 deg; sewage_initial adjustment depth: 0 mm; sewage_length: 222 mm; sewage_diameter_90: no; sewage_diameter_110: yes
Phasing - Phase Created: New Construction
Pset_ManufacturerTypeInformation - Manufacturer: WISA

# IfcFlowTerminal: xt wc frame 83cm_wisa_built in element, RSen_74_PF_FB_built in element xt wc frame 83cm_wisa:xt wc frame 83cm_wisa_built in element:3992872
In: Level 1
Type - ElementType: xt wc frame 83cm_wisa_built in element; PredefinedType: CISTERN; Classification: 4A(74.22) ingebouwde sanitaire voorzieningen (UniFormat); Material: RSen_h2_steel_blue, RSen_n6_PEXa_white
Mechanical - Flow - flush_volume: 0.26486 ft3
General - Rsen_C_content_creator: WISA
Dimensions - Rsen_C_height: 830 mm; Rsen_C_width: 380 mm; Rsen_P_c01_diameter: 15 mm; rs_C_guest_mounting height: 230 mm; Rsen_C_depth: 200 mm; Rsen_P_c02_angle: 0 deg; Rsen_P_c02_diameter: 110 mm
Mechanical - Rsen_P_c02_fixture units: 0; WFU: 0; Rsen_P_c01_fixture units: 0; CWFU: 0; System Classification: Sanitary,Domestic Cold Water
Constraints - Default Elevation: 0 mm; Host: Reference Plane; Elevation: 0 mm; inbouw: no
Text - Rsen_P_c01_definition: c01_cw; Rsen_P_c02_definition: c02_sewage; water connection: G 1/2 left
Materials and Finishes - Rsen_C_material_01: RSen_h2_steel_blue
Identity Data - Rsen_C_code_manufacturer_gln: 8711778000001; URL: www.wisa-sanitair.com/nl/8050453003; Rsen_C_description: WISA XT WC front 83 cm; Rsen_C_model: XT; Rsen_C_code_gtin: 8711778169104; Rsen_C_code_STABU: 53.31; Type Comments: Built-in element wall-hung closet with flushing reservoir; Assembly Description: ingebouwde sanitaire voorzieningen; Assembly Code: 4A(74.22); Rsen_C_type_comments: Inbouwreservoir; Rsen_C_code_manufacturer_product: 8050453003; Manufacturer: WISA; Rsen_C_code_SfB_table1: 74.22; Description: WISA XT WC front 83 cm; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC010145&ArtClassVersion=4; NLRS_C_revit_versie: 2014; Rsen_C_code_ETIM: EC010145; Model: XT; Mark: 1779
Plumbing - sewage_length: 222 mm; sewage_angle: 0 deg; sewage_diameter_90: no; sewage_diameter_110: yes; sewage_initial adjustment depth: 0 mm
Construction - shelf_height: 0 mm; initial adjustment_depth: 200 mm; threaded rod_230: yes; front wall_thickness: 0 mm; threaded rod_180: no; initial adjustment_height: 0 mm
Other - calc_front wall_thickness: 3 mm; calc_sewage: 88 mm; calc_sewage_distance: 88 mm; calc_dist_connection_angle: 88 mm; origin: 0 mm; calc_threaded rod: 230 mm; calc_initial adjustment_depth: 200 mm; calc_shelf_height: 3 mm; Schedule Level: Level: Level 1; calc_sewage_length: 222 mm; calc_initial adjustment_height: 0 mm
Phasing - Phase Created: New Construction
Model Properties - top operation: no; control panel: RSen_74_PF_FB_control panel xt_wisa: ▼ choose; front operation: yes; corner fixation set: no
Pset_ManufacturerTypeInformation - Manufacturer: WISA

# IfcFlowTerminal: xt wc frame 98cm_wisa_built in element, RSen_74_PF_FB_built in element xt wc frame 98cm_wisa:xt wc frame 98cm_wisa_built in element:3992912
In: Level 1
Type - ElementType: xt wc frame 98cm_wisa_built in element; PredefinedType: CISTERN; Classification: 4A(74.22) ingebouwde sanitaire voorzieningen (UniFormat); Material: RSen_h2_steel_blue, RSen_n6_PEXa_white
Constraints - Default Elevation: 0 mm; inbouw: no; Host: Reference Plane; Elevation: 0 mm
Mechanical - Flow - flush_volume: 0.26486 ft3
Dimensions - rs_C_guest_mounting height: 230 mm; Rsen_C_height: 980 mm; Rsen_C_width: 380 mm; Rsen_P_c01_diameter: 15 mm; Rsen_P_c02_angle: 0 deg; Rsen_P_c02_diameter: 110 mm; Rsen_C_depth: 200 mm
Mechanical - CWFU: 0; Rsen_P_c02_fixture units: 0; WFU: 0; Rsen_P_c01_fixture units: 0; System Classification: Sanitary,Domestic Cold Water
Text - Rsen_P_c01_definition: c01_cw; water connection: G 1/2 left; Rsen_P_c02_definition: c02_sewage
General - Rsen_C_content_creator: WISA
Materials and Finishes - Rsen_C_material_01: RSen_h2_steel_blue
Identity Data - Rsen_C_description: WISA XT WC front 98 cm; Rsen_C_type_comments: Built-in element wall-hung closet with flushing reservoir; Rsen_C_code_ETIM_url: http://working.etim-international.com/class_view.aspx?ArtClassID=EC010145&ArtClassVersion=4; Type Comments: Built-in element wall-hung closet with flushing reservoir; Rsen_C_code_manufacturer_product: 8050453002; Rsen_C_code_ETIM: EC010145; Rsen_C_model: XT; Assembly Code: 4A(74.22); NLRS_C_revit_versie: 2014; Rsen_C_code_gtin: 8711778169098; Manufacturer: WISA; Description: WISA XT WC front 98 cm; Model: XT; URL: www.wisa-sanitair.com/nl/8050453002; Rsen_C_code_manufacturer_gln: 8711778000001; Rsen_C_code_STABU: 53.31; Assembly Description: ingebouwde sanitaire voorzieningen; Rsen_C_code_SfB_table1: 74.22; Mark: 1781
Model Properties - top operation: no; corner fixation set: no; control panel: RSen_74_PF_FB_control panel xt_wisa: ▼ choose; front operation: yes
Other - calc_dist_connection_angle: 88 mm; calc_sewage_length: 222 mm; calc_initial adjustment_height: 0 mm; calc_initial adjustment_depth: 200 mm; calc_threaded rod: 230 mm; origin: 0 mm; calc_sewage_distance: 88 mm; calc_sewage: 88 mm; Schedule Level: Level: Level 1; calc_shelf_height: 3 mm; calc_front wall_thickness: 3 mm
Phasing - Phase Created: New Construction
Construction - threaded rod_180: no; shelf_height: 0 mm; threaded rod_230: yes; initial adjustment_height: 0 mm; front wall_thickness: 0 mm; initial adjustment_depth: 200 mm
Plumbing - sewage_angle: 0 deg; sewage_length: 222 mm; sewage_initial adjustment depth: 0 mm; sewage_diameter_90: no; sewage_diameter_110: yes
Pset_ManufacturerTypeInformation - Manufacturer: WISA

# IfcMember: 74_WISA_logo, 74_WISA_logo:74_WISA_logo:2122905
In: Level 1
Type - ElementType: 74_WISA_logo; Classification:  (UniFormat); Material: WISA blauw
Constraints - Host: Level : Level 1; Moves With Nearby Elements: no; Level: Level: Level 1; Offset: 0 mm
Phasing - Phase Created: New Construction
Dimensions - Volume: 4.01625 ft3
Pset_MemberCommon - Reference: 74_WISA_logo; LoadBearing: yes; IsExternal: no; Span: 50 mm; Slope: 0 deg
